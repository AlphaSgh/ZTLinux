## Kconfig
```kconfig
config     SECURITY_ZTLINUX
   bool     "ZTLinux support"
   depends on SECURITY
   default     n
   help
        introduction of ZTLinux
```
